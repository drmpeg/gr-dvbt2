<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dvbt2_tx</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000000</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/re/xfer/vv256.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>dvbt2_bbheader_bb</key>
<param><key>id</key><value>dvbt2_bbheader_bb_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C4_5</value></param>
</block>
<block>
<key>dvbt2_bbscrambler_bb</key>
<param><key>id</key><value>dvbt2_bbscrambler_bb_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C4_5</value></param>
</block>
<block>
<key>dvbt2_bch_bb</key>
<param><key>id</key><value>dvbt2_bch_bb_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C4_5</value></param>
</block>
<block>
<key>dvbt2_ldpc_bb</key>
<param><key>id</key><value>dvbt2_ldpc_bb_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C4_5</value></param>
</block>
<block>
<key>dvbt2_interleaver_bb</key>
<param><key>id</key><value>dvbt2_interleaver_bb_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C4_5</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
</block>
<block>
<key>dvbt2_modulator_bc</key>
<param><key>id</key><value>dvbt2_modulator_bc_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
</block>
<block>
<key>dvbt2_cellinterleaver_cc</key>
<param><key>id</key><value>dvbt2_cellinterleaver_cc_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>fecblocks</key><value>168</value></param>
<param><key>tiblocks</key><value>3</value></param>
</block>
<block>
<key>dvbt2_framemapper_cc</key>
<param><key>id</key><value>dvbt2_framemapper_cc_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C4_5</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
<param><key>fecblocks</key><value>168</value></param>
<param><key>tiblocks</key><value>3</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_16K</value></param>
<param><key>guardinterval</key><value>GI_1_32</value></param>
<param><key>l1constellation</key><value>L1_MOD_64QAM</value></param>
<param><key>pilotpattern</key><value>PILOT_PP6</value></param>
<param><key>t2frames</key><value>2</value></param>
<param><key>numdatasyms</key><value>100</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/re/xfer/vvbb.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dvbt2_freqinterleaver_cc</key>
<param><key>id</key><value>dvbt2_freqinterleaver_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_16K</value></param>
<param><key>pilotpattern</key><value>PILOT_PP6</value></param>
<param><key>numdatasyms</key><value>100</value></param>
</block>
<connection><source_block_id>dvbt2_bch_bb_0</source_block_id><sink_block_id>dvbt2_ldpc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_bbscrambler_bb_0</source_block_id><sink_block_id>dvbt2_bch_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_ldpc_bb_0</source_block_id><sink_block_id>dvbt2_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_interleaver_bb_0</source_block_id><sink_block_id>dvbt2_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_modulator_bc_0</source_block_id><sink_block_id>dvbt2_cellinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_cellinterleaver_cc_0</source_block_id><sink_block_id>dvbt2_framemapper_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_bbheader_bb_0</source_block_id><sink_block_id>dvbt2_bbscrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>dvbt2_bbheader_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_framemapper_cc_0</source_block_id><sink_block_id>dvbt2_freqinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_freqinterleaver_cc_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
