<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vv016_256qam34</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8000000</value></param>
</block>
<block>
<key>dvbt2_bbscrambler_bb</key>
<param><key>id</key><value>dvbt2_bbscrambler_bb_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C3_4</value></param>
</block>
<block>
<key>dvbt2_bch_bb</key>
<param><key>id</key><value>dvbt2_bch_bb_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C3_4</value></param>
</block>
<block>
<key>dvbt2_ldpc_bb</key>
<param><key>id</key><value>dvbt2_ldpc_bb_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C3_4</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>429000000</value></param>
<param><key>y_per_div</key><value>20</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>10</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>600,600</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>dvbt2_bbheader_bb</key>
<param><key>id</key><value>dvbt2_bbheader_bb_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C3_4</value></param>
<param><key>mode</key><value>FECFRAME_SHORT</value></param>
<param><key>inband</key><value>INBAND_OFF</value></param>
<param><key>fecblocks</key><value>168</value></param>
<param><key>tsrate</key><value>4000000</value></param>
</block>
<block>
<key>dvbt2_modulator_bc</key>
<param><key>id</key><value>dvbt2_modulator_bc_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
</block>
<block>
<key>dvbt2_cellinterleaver_cc</key>
<param><key>id</key><value>dvbt2_cellinterleaver_cc_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>fecblocks</key><value>200</value></param>
<param><key>tiblocks</key><value>3</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>input_size</key><value>32768</value></param>
<param><key>cp_len</key><value>32768/128</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>dvbt2_p1insertion_cc</key>
<param><key>id</key><value>dvbt2_p1insertion_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize1</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>fftsize2</key><value>FFTSIZE_2K</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>preamble2</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>showlevels</key><value>SHOWLEVELS_OFF</value></param>
<param><key>vclip</key><value>3.3</value></param>
</block>
<block>
<key>dvbt2_interleaver_bb</key>
<param><key>id</key><value>dvbt2_interleaver_bb_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C3_4</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
</block>
<block>
<key>dvbt2_framemapper_cc</key>
<param><key>id</key><value>dvbt2_framemapper_cc_0</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>rate</key><value>C3_4</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
<param><key>fecblocks</key><value>200</value></param>
<param><key>tiblocks</key><value>3</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize1</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>fftsize2</key><value>FFTSIZE_2K</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>l1constellation</key><value>L1_MOD_64QAM</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>t2frames</key><value>2</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>paprmode1</key><value>PAPR_TR</value></param>
<param><key>paprmode2</key><value>PAPR_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>preamble2</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>inputmode</key><value>FECFRAME_NORMAL</value></param>
<param><key>reservedbiasbits</key><value>RESERVED_OFF</value></param>
<param><key>l1scrambled</key><value>L1_SCRAMBLED_OFF</value></param>
<param><key>inband</key><value>INBAND_OFF</value></param>
</block>
<block>
<key>dvbt2_freqinterleaver_cc</key>
<param><key>id</key><value>dvbt2_freqinterleaver_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>paprmode1</key><value>PAPR_TR</value></param>
<param><key>paprmode2</key><value>PAPR_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>preamble2</key><value>PREAMBLE_T2_SISO</value></param>
</block>
<block>
<key>dvbt2_pilotgenerator_cc</key>
<param><key>id</key><value>dvbt2_pilotgenerator_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>paprmode1</key><value>PAPR_TR</value></param>
<param><key>paprmode2</key><value>PAPR_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>preamble2</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>misogroup</key><value>MISO_TX1</value></param>
<param><key>equalization</key><value>EQUALIZATION_OFF</value></param>
<param><key>bandwidth</key><value>BANDWIDTH_1_7_MHZ</value></param>
</block>
<block>
<key>dvbt2_paprtr_cc</key>
<param><key>id</key><value>dvbt2_paprtr_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>paprmode1</key><value>PAPR_TR</value></param>
<param><key>paprmode2</key><value>PAPR_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>vclip</key><value>3.3</value></param>
<param><key>iterations</key><value>3</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/re/xfer/vv016.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/re/xfer/vv.cfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>dvbt2_bch_bb_0</source_block_id><sink_block_id>dvbt2_ldpc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_bbscrambler_bb_0</source_block_id><sink_block_id>dvbt2_bch_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_ldpc_bb_0</source_block_id><sink_block_id>dvbt2_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_interleaver_bb_0</source_block_id><sink_block_id>dvbt2_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_modulator_bc_0</source_block_id><sink_block_id>dvbt2_cellinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_cellinterleaver_cc_0</source_block_id><sink_block_id>dvbt2_framemapper_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_bbheader_bb_0</source_block_id><sink_block_id>dvbt2_bbscrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>dvbt2_bbheader_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_framemapper_cc_0</source_block_id><sink_block_id>dvbt2_freqinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_freqinterleaver_cc_0</source_block_id><sink_block_id>dvbt2_pilotgenerator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_p1insertion_cc_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>dvbt2_p1insertion_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_paprtr_cc_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbt2_pilotgenerator_cc_0</source_block_id><sink_block_id>dvbt2_paprtr_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
